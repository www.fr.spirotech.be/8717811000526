Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB050_FBA08_INT-EN.ifc
Time: 2025-08-05T18:34:05+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort, InPort_2154540_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB_INT-EN:AB050_FBA08, M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB_INT-EN:AB050_FBA08:2154540
In: F00
Type - Material: <Unnamed>, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Bottom piece offset: 34.9986 mm; Connection Diameter: 12.7 mm; d1: 64.9992 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 12.7 mm; Connection Outer Diameter: 21.3 mm; H: 111.999 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Automatic air vent Solar - Brass - AutoClose - 1/2"; Article Type: AB050_FBA08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Automatic air vent Solar - Brass - AutoClose - 1/2"; EMCS Version: 2.0; ETIM Article Class: EC010117; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811018484; Manufacturer: Spirotech; Manufacturer Art. No.: AB050_FBA08; Manufacturer URL: https://www.spirotech.com/8717811018484; MEPcontent Class: SEPARATOR_AIR; Model: AB050_FBA08; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: AB050_FBA08; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: AB050_FBA08; sets with these values: 2
Other - Family: M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroTop_AB_INT-EN: AB050_FBA08; Type: AB050_FBA08; Type Id: 2154519
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 12.7 mm; Minimum Size: 12.7 mm; Volume: 0.000149016 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
